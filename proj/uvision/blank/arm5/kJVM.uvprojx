# Keil uVision project kJVM.uvprojx, settings and files
target nrf51422_xxac (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_NRF6310 __CORTEX_M0 TARGET_MCU_NRF51_16K TARGET_MCU_NRF51822  TARGET_NRF51822_MKIT TARGET_CORTEX_M  TARGET_NRF5182  ARM_MATH_CM0  TOOLCHAIN_ARM_STD  __MBED__=1  TARGET_NORDIC  TARGET_MCU_NRF51  TARGET_MCU_NORDIC_16K  TARGET_M0  TOOLCHAIN_ARM  MBED_BUILD_TIMESTAMP=1448486316.17  TARGET_MCU_NRF51_16K_S130  __ASSERT_MSG
  c misc: --cpp
  c include: ..\..\..\mbed\api;..\..\..\mbed\common;..\..\..\mbed\hal;..\..\..\mbed\targets;..\..\..\mbed\targets\cmsis\TARGET_NORDIC\TARGET_MCU_NRF51822;..\..\..\mbed\targets\hal\TARGET_NORDIC\TARGET_MCU_NRF51822\TARGET_NRF51822_MKIT;..\..\..\mbed\targets\hal\TARGET_NORDIC\TARGET_MCU_NRF51822
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group mbed_api
    ../../../mbed/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h platform.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
  group mbed_common
    ../../../mbed/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp LocalFileSystem.cpp lp_ticker_api.c mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp ticker_api.c Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group mbed_hal
    ../../../mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
  group mbed_target_hal
    ../../../mbed/targets/hal/TARGET_NORDIC/TARGET_MCU_NRF51822/: analogin_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c objects.h PeripheralNames.h pinmap.c port_api.c PortNames.h pwmout_api.c serial_api.c sleep.c spi_api.c twi_config.h twi_master.c twi_master.h us_ticker.c
    ../../../mbed/targets/hal/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT/: device.h PinNames.h
  group src
    ../../../src/: main.cpp
  group RTT
    ../../../SEGGER_RTT/: SEGGER_RTT.cpp SEGGER_RTT.h SEGGER_RTT_Conf.h
software components: CMSIS:CORE 4.3.0, Device:Startup 8.0.3
