# Keil uVision project kJVM.uvprojx, settings and files
target nrf51422_xxac_s110 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_NRF6310 BSP_DEFINES_ONLY __CORTEX_M0 TARGET_MCU_NRF51_16K TARGET_MCU_NRF51822  TARGET_NRF51822_MKIT TARGET_CORTEX_M  TARGET_NRF5182  ARM_MATH_CM0  TOOLCHAIN_ARM_STD  __MBED__=1  TARGET_NORDIC  TARGET_MCU_NRF51  TARGET_MCU_NORDIC_16K  TARGET_M0  TOOLCHAIN_ARM  MBED_BUILD_TIMESTAMP=1448486316.17  TARGET_MCU_NRF51_16K_S110  __ASSERT_MSG
  c misc: --cpp
  c include: ..\..\..\mbed\api;..\..\..\mbed\common;..\..\..\mbed\hal;..\..\..\mbed\targets;..\..\..\mbed\targets\cmsis\TARGET_NORDIC\TARGET_MCU_NRF51822;..\..\..\mbed\targets\hal\TARGET_NORDIC\TARGET_MCU_NRF51822;..\..\..\mbed\targets\hal\TARGET_NORDIC\TARGET_MCU_NRF51822\TARGET_NRF51822_MKIT;..\..\..\SEGGER_RTT;..\..\..\BLE_API;..\..\..\BLE_API\source\nRF51822;..\..\..\BLE_API\source\nRF51822\btle;..\..\..\BLE_API\source\nRF51822\btle\custom;..\..\..\BLE_API\source\nRF51822\common;..\..\..\BLE_API\source\services;..\..\..\BLE_API\ble\services
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group mbed_api
    ../../../mbed/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h platform.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
  group mbed_common
    ../../../mbed/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp LocalFileSystem.cpp lp_ticker_api.c mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp ticker_api.c Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group mbed_hal
    ../../../mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
  group mbed_target_hal
    ../../../mbed/targets/hal/TARGET_NORDIC/TARGET_MCU_NRF51822/: analogin_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c objects.h PeripheralNames.h pinmap.c port_api.c PortNames.h pwmout_api.c serial_api.c sleep.c spi_api.c twi_config.h twi_master.c twi_master.h us_ticker.c
    ../../../mbed/targets/hal/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT/: device.h PinNames.h
  group mbed_ble_services
    ../../../BLE_API/ble/services/: BatteryService.h DeviceInformationService.h DFUService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h iBeacon.h LinkLossService.h UARTService.h URIBeaconConfigService.h
  group RTT
    ../../../SEGGER_RTT/: SEGGER_RTT.cpp SEGGER_RTT.h SEGGER_RTT_Conf.h
  group mbed_ble
    ../../../BLE_API/ble/: BLE.h blecommon.h BLEInstanceBase.h CallChainOfFunctionPointersWithContext.h DiscoveredCharacteristic.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h
  group mbed_ble_api_service
    ../../../BLE_API/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
  group mbed_ble_api
    ../../../BLE_API/source/: BLE.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
  group src
    ../../../src/: main.cpp
  group mbed_ble_nrf51822
    ../../../BLE_API/source/nRF51822/: nRF5xDiscoveredCharacteristic.cpp nRF5xDiscoveredCharacteristic.h nRF5xGap.cpp nRF5xGap.h nRF5xGattClient.cpp nRF5xGattClient.h nRF5xGattServer.cpp nRF5xGattServer.h nRF5xn.cpp nRF5xn.h nRF5xSecurityManager.cpp nRF5xSecurityManager.h nRF5xServiceDiscovery.cpp nRF5xServiceDiscovery.h projectconfig.h
    ../../../BLE_API/source/nRF51822/btle/: btle.cpp btle.h btle_advertising.cpp btle_advertising.h btle_discovery.cpp btle_discovery.h btle_gap.cpp btle_gap.h btle_security.cpp btle_security.h
    ../../../BLE_API/source/nRF51822/btle/custom/: custom_helper.cpp custom_helper.h
software components: CMSIS:CORE 4.3.0, Board Support:bsp 7.2.0, Device:Startup 8.2.0, nRF_BLE:BLE_Modules:ble_advdata 1.1.1, nRF_BLE:BLE_Modules:ble_radio_notification 1.1.1, nRF_BLE:BLE_Modules:ble_service_common 1.1.1, nRF_BLE:BLE_Modules:device_manager 1.1.1, nRF_BLE:BLE_Services:ble_bas 1.1.1, nRF_BLE:BLE_Services:ble_dis 1.1.1, nRF_Drivers:ble_flash 1.2.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:nrf_error 1.2.1, nRF_Drivers:nrf_gpio 1.2.1, nRF_Drivers:nrf_soc 1.2.1, nRF_Drivers:pstorage 1.2.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_trace 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_SoftDevice:Internal:sd_common 1.1.1, nRF_SoftDevice:Internal:softdevice_present 1.1.1, nRF_SoftDevice:s110 7.1.0-3
